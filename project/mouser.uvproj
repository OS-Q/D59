# Keil uVision project mouser.uvproj, settings and files
target qitas (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: mouser +hex
  c flags: Optimize=8 SizeSpeed=1
  group user
    ./user/: MAIN.C KM_CHANGE4V10_48M.LIB
